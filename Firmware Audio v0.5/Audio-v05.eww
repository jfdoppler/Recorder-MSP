<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Firmware Audio v0.4\ejemplo1\ejemplo1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


